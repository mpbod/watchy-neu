#include "watchy/ui.h"

#include <stddef.h>

/* Public-domain 5x7 column font, ASCII 0x20 through 0x7f. Each low bit is the
 * top pixel. Lowercase is retained so package names and network state remain
 * readable without a second graphics dependency. */
static const uint8_t FONT[96][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5f,0x00,0x00},
    {0x00,0x07,0x00,0x07,0x00},{0x14,0x7f,0x14,0x7f,0x14},
    {0x24,0x2a,0x7f,0x2a,0x12},{0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
    {0x00,0x1c,0x22,0x41,0x00},{0x00,0x41,0x22,0x1c,0x00},
    {0x14,0x08,0x3e,0x08,0x14},{0x08,0x08,0x3e,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},
    {0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3e,0x51,0x49,0x45,0x3e},{0x00,0x42,0x7f,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4b,0x31},
    {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
    {0x3c,0x4a,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1e},
    {0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
    {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3e},{0x7e,0x11,0x11,0x11,0x7e},
    {0x7f,0x49,0x49,0x49,0x36},{0x3e,0x41,0x41,0x41,0x22},
    {0x7f,0x41,0x41,0x22,0x1c},{0x7f,0x49,0x49,0x49,0x41},
    {0x7f,0x09,0x09,0x09,0x01},{0x3e,0x41,0x49,0x49,0x7a},
    {0x7f,0x08,0x08,0x08,0x7f},{0x00,0x41,0x7f,0x41,0x00},
    {0x20,0x40,0x41,0x3f,0x01},{0x7f,0x08,0x14,0x22,0x41},
    {0x7f,0x40,0x40,0x40,0x40},{0x7f,0x02,0x0c,0x02,0x7f},
    {0x7f,0x04,0x08,0x10,0x7f},{0x3e,0x41,0x41,0x41,0x3e},
    {0x7f,0x09,0x09,0x09,0x06},{0x3e,0x41,0x51,0x21,0x5e},
    {0x7f,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
    {0x01,0x01,0x7f,0x01,0x01},{0x3f,0x40,0x40,0x40,0x3f},
    {0x1f,0x20,0x40,0x20,0x1f},{0x3f,0x40,0x38,0x40,0x3f},
    {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},
    {0x61,0x51,0x49,0x45,0x43},{0x00,0x7f,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7f,0x00},
    {0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
    {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},
    {0x7f,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7f},{0x38,0x54,0x54,0x54,0x18},
    {0x08,0x7e,0x09,0x01,0x02},{0x0c,0x52,0x52,0x52,0x3e},
    {0x7f,0x08,0x04,0x04,0x78},{0x00,0x44,0x7d,0x40,0x00},
    {0x20,0x40,0x44,0x3d,0x00},{0x7f,0x10,0x28,0x44,0x00},
    {0x00,0x41,0x7f,0x40,0x00},{0x7c,0x04,0x18,0x04,0x78},
    {0x7c,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
    {0x7c,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7c},
    {0x7c,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3f,0x44,0x40,0x20},{0x3c,0x40,0x40,0x20,0x7c},
    {0x1c,0x20,0x40,0x20,0x1c},{0x3c,0x40,0x30,0x40,0x3c},
    {0x44,0x28,0x10,0x28,0x44},{0x0c,0x50,0x50,0x50,0x3c},
    {0x44,0x64,0x54,0x4c,0x44},{0x00,0x08,0x36,0x41,0x00},
    {0x00,0x00,0x7f,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},
    {0x10,0x08,0x08,0x10,0x08},{0x00,0x06,0x09,0x09,0x06},
};

static void pixel(watchy_canvas_t *canvas, int16_t x, int16_t y, bool black) {
    size_t offset;
    uint8_t mask;
    if (canvas == NULL || canvas->pixels == NULL || canvas->format != WATCHY_PIXEL_MONO ||
        x < 0 || y < 0 || x >= (int16_t)canvas->width || y >= (int16_t)canvas->height) {
        return;
    }
    offset = (size_t)y * canvas->stride + (size_t)x / 8u;
    mask = (uint8_t)(0x80u >> ((unsigned)x & 7u));
    if (black) {
        canvas->pixels[offset] &= (uint8_t)~mask;
    } else {
        canvas->pixels[offset] |= mask;
    }
}

void watchy_ui_rect(watchy_canvas_t *canvas,
                    int16_t x,
                    int16_t y,
                    int16_t width,
                    int16_t height,
                    bool black) {
    for (int16_t row = 0; row < height; ++row) {
        for (int16_t column = 0; column < width; ++column) {
            pixel(canvas, (int16_t)(x + column), (int16_t)(y + row), black);
        }
    }
}

void watchy_ui_fill(watchy_canvas_t *canvas, bool black) {
    if (canvas != NULL) {
        watchy_ui_rect(canvas, 0, 0, (int16_t)canvas->width, (int16_t)canvas->height, black);
    }
}

void watchy_ui_draw_text(watchy_canvas_t *canvas,
                         int16_t x,
                         int16_t y,
                         const char *text,
                         uint8_t scale,
                         bool black) {
    int16_t cursor = x;
    if (canvas == NULL || text == NULL || scale == 0u) {
        return;
    }
    while (*text != '\0') {
        unsigned char character = (unsigned char)*text++;
        if (character < 0x20u || character > 0x7fu) {
            character = '?';
        }
        for (uint8_t column = 0u; column < 5u; ++column) {
            const uint8_t bits = FONT[character - 0x20u][column];
            for (uint8_t row = 0u; row < 7u; ++row) {
                if ((bits & (uint8_t)(1u << row)) != 0u) {
                    watchy_ui_rect(canvas,
                                   (int16_t)(cursor + column * scale),
                                   (int16_t)(y + row * scale),
                                   scale, scale, black);
                }
            }
        }
        cursor = (int16_t)(cursor + 6 * scale);
    }
}
